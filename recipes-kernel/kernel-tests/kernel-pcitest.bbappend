do_configure_mcm-imx8m-nano() {
	:
}
